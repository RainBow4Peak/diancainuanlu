# Keil uVision project guolu.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: guolu
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\APP;.\APP\adc;.\APP\beep;.\APP\exti;.\APP\key;.\APP\led;.\APP\time;.\Public;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c global.c led_ctrl.c set_param.c stm32f10x_it.c capture.c mode_Relay.c wifi.c
  group Public
    ./Public/: system.c SysTick.c usart.c stm32f10x_flash.h stm32_flash.c stm32_flash.h
  group APP
    ./APP/adc/: adc.c
    ./APP/exti/: exti.c
    ./APP/key/: key.c
    ./APP/led/: led.c
    ./APP/time/: time.c
    ./APP/: TimeRead.c
software components: CMSIS:CORE 3.40.0, Data Exchange:JSON:Jansson 2.7.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
